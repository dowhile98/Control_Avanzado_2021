# Keil uVision project ControlPID.uvprojx, settings and files
target ControlPID (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ControlPID +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,MATLAB_PROJECT,USE_HAL_DRIVER,STM32L412xx
  c include: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Core/Include; ../Drivers/CMSIS/DSP/Include; ../ControlPID/Inc; "C:/Program Files/Polyspace/R2020a/simulink/include"
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l412xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
    ../ControlPID/Src/: getBuffPtr.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group MATLAB
    D:/UNAC/CICLO-9/CONTROL AVANZADO/CODIGO/MATLAB/ControlPID/ControlPID/Src/: ControlPID.c ControlPID_EXTI.c ControlPID_TIM.c ControlPID_USART.c rtGetInf.c rtGetNaN.c rt_nonfinite.c
software components: CMSIS:CORE 4.3.0
